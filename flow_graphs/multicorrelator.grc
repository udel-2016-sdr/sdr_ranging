<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multicorrelator</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Multicorrelator</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>poll_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>poll_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>3</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>controlled_delay</key>
<param><key>id</key><value>controlled_delay_early</value></param>
<param><key>name</key><value>early</value></param>
<param><key>init_delay</key><value>0</value></param>
</block>
<block>
<key>controlled_delay</key>
<param><key>id</key><value>controlled_delay_late</value></param>
<param><key>name</key><value>late</value></param>
<param><key>init_delay</key><value>0</value></param>
</block>
<block>
<key>controlled_delay</key>
<param><key>id</key><value>controlled_delay_prompt</value></param>
<param><key>name</key><value>prompt</value></param>
<param><key>init_delay</key><value>0</value></param>
</block>
<block>
<key>correlator_kernel</key>
<param><key>id</key><value>correlator_kernel_early</value></param>
<param><key>int_period</key><value>(samp_rate / frequency) * int_mult</value></param>
</block>
<block>
<key>correlator_kernel</key>
<param><key>id</key><value>correlator_kernel_late</value></param>
<param><key>int_period</key><value>(samp_rate / frequency) * int_mult</value></param>
</block>
<block>
<key>correlator_kernel</key>
<param><key>id</key><value>correlator_kernel_prompt</value></param>
<param><key>int_period</key><value>(samp_rate / frequency) * int_mult</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>int_mult</value></param>
<param><key>label</key><value>Integration Period Multiplier</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>multicorr_state_machine_v1</key>
<param><key>id</key><value>multicorr_state_machine_v1_0</value></param>
<param><key>early_dly_cont_name</key><value>early</value></param>
<param><key>late_dly_cont_name</key><value>late</value></param>
<param><key>max_delay</key><value>samp_rate / frequency</value></param>
<param><key>prompt_dly_cont_name</key><value>prompt</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>corr_values</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>delays</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>recv</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>command</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>ref</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>poll_rate</value></param>
<param><key>label</key><value>State Machine Poll Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>sm_new_delay</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>int1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>sm_new_delay</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>int1</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>multicorr_state_machine_v1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>controlled_delay_early</source_block_id><sink_block_id>correlator_kernel_early</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>controlled_delay_late</source_block_id><sink_block_id>correlator_kernel_late</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>controlled_delay_prompt</source_block_id><sink_block_id>correlator_kernel_prompt</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correlator_kernel_early</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correlator_kernel_late</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correlator_kernel_prompt</source_block_id><sink_block_id>blocks_complex_to_real_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multicorr_state_machine_v1_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>delay_cmd</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>multicorr_state_machine_v1_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correlator_kernel_early</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correlator_kernel_late</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correlator_kernel_prompt</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>multicorr_state_machine_v1_0</sink_block_id><source_key>out</source_key><sink_key>sm_cmd</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>controlled_delay_early</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>controlled_delay_late</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>controlled_delay_prompt</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>controlled_delay_early</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>controlled_delay_late</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>controlled_delay_prompt</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
