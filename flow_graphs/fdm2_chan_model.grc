<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fdm2_chan_model</value></param>
<param><key>category</key><value>[GRC Hier Blocks]/FDM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FDM (2 Slot) Channel Model</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch_width</value></param>
<param><key>label</key><value>Channel Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>seed</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>fdm2_dmux</key>
<param><key>id</key><value>fdm2_dmux_0</value></param>
<param><key>ch_width</key><value>ch_width</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fdm2_mux</key>
<param><key>id</key><value>fdm2_mux_0</value></param>
<param><key>ch_width</key><value>ch_width</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>label</key><value>Noise Voltage</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>seed</value></param>
<param><key>label</key><value>Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>fdm2_dmux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fdm2_dmux_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fdm2_dmux_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fdm2_mux_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fdm2_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>fdm2_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
